Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFooting: 800*800 (4)
Tekla Commun - Niveau bas: -0.800; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 241; Classe: 8; Matériau: VERRE; Profil: 800*800; Nom: SEMELLE
Tekla Quantités - Poids: 1295.4 kg; Volume: 0.5 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 3 m2; Surface nette: 3.8 m2; Hauteur: 800 mm; Largeur: 800 mm; Longueur: 800 mm
BaseQuantities - Length: 800 mm; OuterSurfaceArea: 3.84 m2; GrossSurfaceArea: 3.84 m2; CrossSectionArea: 0.64 m2; NetVolume: 0.512 m3; GrossVolume: 0.512 m3; NetWeight: 1295.36 kg; GrossWeight: 1295.36 kg; Width: 800 mm; Height: 800 mm

# IfcFooting: 850*130 (10)
In: Undefined
Description: 850*130; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.650; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 244; Classe: 8; Matériau: VERRE; Profil: 850*130; Nom: SEMELLE
Tekla Quantités - Poids: 181.7 kg; Volume: 0.1 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 8.2 m2; Surface nette: 1.5 m2; Hauteur: 850 mm; Largeur: 130 mm; Longueur: 650 mm
BaseQuantities - Length: 650 mm; OuterSurfaceArea: 1.495 m2; GrossSurfaceArea: 1.495 m2; CrossSectionArea: 0.1105 m2; NetVolume: 0.071825 m3; GrossVolume: 0.071825 m3; NetWeight: 181.717 kg; GrossWeight: 181.717 kg; Width: 130 mm; Height: 850 mm

# IfcMechanicalFastener: Bolt assembly (15999)
In: Undefined
NominalDiameter: 12 mm; Material: 8.8
Tekla Boulons - Diamètre rondelle: 12 mm; Type rondelle: PLA-8.8; Nom rondelle: RONDELLE-M12-PLA-8.8; Type écrou: E-8.8; Nom écrou: ECROU-M12-E-8.8; Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Diamètre du trou: 14 mm; Lieu Boulonnage: Montage; Diamètre: 12 mm; Standard: 8.8
Name | NominalLength (mm) | Quantité de rondelle | Quantité d'écrou | Quantité | Longueur (mm) | Nom
196 x Bolt assembly | 2 | 0 | 0 | 1 | 2 | M12*25
878 x Bolt assembly | 25 | 0 | 1 | 1 | 25 | M12*25
9050 x Bolt assembly | 2 | 0 | 0 | 2 | 2 | M12*25
2355 x Bolt assembly | 25 | 0 | 2 | 2 | 25 | M12*25
34 x Bolt assembly | 1.49976 | 0 | 0 | 1 | 1.5 | M12*25
2338 x Bolt assembly | 1.5 | 0 | 0 | 1 | 1.5 | M12*25
14 x Bolt assembly | 3.93 | 0 | 0 | 1 | 3.9 | M12*25
6 x Bolt assembly | 4 | 0 | 0 | 1 | 3.9 | M12*25
135 x Bolt assembly | 25 | 0 | 4 | 4 | 25 | M12*25
2 x Bolt assembly | 100 | 0 | 1 | 1 | 100 | M12*100
136 x Bolt assembly | 4 | 0 | 0 | 2 | 3.9 | M12*25
24 x Bolt assembly | 4.00002 | 0 | 0 | 2 | 3.9 | M12*25
800 x Bolt assembly | 1.5 | 0 | 0 | 2 | 1.5 | M12*25
27 x Bolt assembly | 4 | 0 | 0 | 4 | 3.9 | M12*25
4 x Bolt assembly | 25 | 4 | 4 | 4 | 25 | M12*25

# IfcMember: SADEF-C+200X1.50 (134)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000723 m2
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x ARBA | STEEL/Steel_Undefined | +0.255 | +2.695 | A0(?) | 245 | 6 | Steel_Undefined | ARBA | 18.7 | 3.3 | 3300.1 | 3300.05 | 2.83804 | 0.00249484 | 0.00238594 | 19.5845 | 18.7296
2 x ARBA | STEEL/Steel_Undefined | +2.712 | +5.146 | A0(?) | 245 | 6 | Steel_Undefined | ARBA | 18.7 | 3.3 | 3291.4 | 3291.43 | 2.83063 | 0.00248832 | 0.0023797 | 19.5333 | 18.6806
2 x ARBA | STEEL/Steel_Undefined | +0.255 | +5.146 | A0(?) | 245 | 6 | Steel_Undefined | ARBA | 38.1 | 6.9 | 6711.5 | 6711.53 | 5.77191 | 0.00507391 | 0.00485243 | 39.8302 | 38.0916
4 x POUTRE | STEEL/S235JR | +6.162 | +6.671 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x POUTRE | STEEL/S235JR | +6.223 | +6.732 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
12 x POUTRE | STEEL/S235JR | +5.926 | +6.732 | A0(?) | 62 | 99 | S235JR | POUTRE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
4 x POUTRE | STEEL/S235JR | +5.479 | +5.988 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x POUTRE | STEEL/S235JR | +5.845 | +6.354 | A0(?) | 63 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
12 x POUTRE | STEEL/S235JR | +5.548 | +6.354 | A0(?) | 62 | 99 | S235JR | POUTRE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
12 x POUTRE | STEEL/S235JR | +5.182 | +5.988 | A0(?) | 62 | 99 | S235JR | POUTRE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
8 x RENFORT-ATTACHE | STEEL/S235JR | +5.350 | +6.171 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
12 x RENFORT-ATTACHE | STEEL/S235JR | +6.238 | +7.059 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
12 x RENFORT-ATTACHE | STEEL/S235JR | +5.700 | +6.521 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
12 x RENFORT-ATTACHE | STEEL/S235JR | +5.030 | +5.851 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
12 x RENFORT-ATTACHE | STEEL/S235JR | +4.909 | +5.730 | RA0(?) | 62 | 99 | S235JR | RENFORT-ATTACHE | 4.5 | 0.9 | 800 | 800 | 0.688 | 0.0006048 | 0.0005784 | 4.74768 | 4.54044
4 x RENFORT-ATTACHE | STEEL/S235JR | +6.534 | +7.059 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.997 | +6.521 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.647 | +6.171 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.327 | +5.851 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.205 | +5.730 | RA0(?) | 63 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777

# IfcPlate: PL2*100 (20)
In: Undefined
Description: PL2*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLA0(?); Repère d'assemblage: PLA0(?); Phase: 247; Classe: 99; Matériau: S235JR; Profil: PL2*100; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PLA0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000004 m2
Name | Niveau bas | Niveau haut | Poids (kg) | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLAT | +0.179 | +0.279 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
2 x PLAT | +2.679 | +2.779 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
4 x PLAT | +4.856 | +4.956 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
4 x PLAT | +4.856 | +4.956 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
4 x PLAT | +0.179 | +0.279 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
4 x PLAT | +2.679 | +2.779 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008

# IfcPlate: PL4*100 (16)
In: Undefined
Description: PL4*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PL0(?); Repère d'assemblage: PL0(?); Classe: 99; Matériau: S235JR; Profil: PL4*100; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.8 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 4 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PL0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000016 m2
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLAT | +6.690 | +6.738 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +6.488 | +6.536 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.458 | +5.517 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.660 | +5.719 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.999 | +6.058 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +6.201 | +6.260 | 246 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
4 x PLAT | +2.518 | +2.889 | 245 | 1.3 | 420 | 0.0881704 | 0.042005 | 0.00016802

# IfcPlate: PL4*162 (4)
In: Undefined
Description: PL4*162; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +6.275; Niveau haut: +6.498; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 63; Classe: 99; Matériau: S235JR; Profil: PL4*162; Nom: GOUSSET
Tekla Quantités - Poids: 2.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.9 m2; Surface nette: 0.1 m2; Hauteur: 161.8 mm; Largeur: 4 mm; Longueur: 418.2 mm
BaseQuantities - Width: 161.79 mm; NetArea: 0.139971 m2; GrossArea: 0.0676654 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000270662 m3; GrossVolume: 0.000270662 m3

# IfcPlate: PL4*400 (4)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +5.054; Niveau haut: +5.636; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 261; Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: GOUSSET
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 400.2 mm; Largeur: 4 mm; Longueur: 582 mm
BaseQuantities - Width: 400.158 mm; NetArea: 0.448656 m2; GrossArea: 0.232894 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000882055 m3; GrossVolume: 0.000882055 m3

# IfcPlate: PL4*450 (2)
In: Undefined
Description: PL4*450; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +6.665; Niveau haut: +7.115; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 261; Classe: 99; Matériau: S235JR; Profil: PL4*450; Nom: GOUSSET
Tekla Quantités - Poids: 8.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 450.1 mm; Largeur: 4 mm; Longueur: 682.4 mm
BaseQuantities - Width: 450.149 mm; NetArea: 0.537583 m2; GrossArea: 0.307168 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00105873 m3; GrossVolume: 0.00105873 m3

# IfcPlate: PL4*674 (3)
In: Undefined
Description: PL4*674; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +6.272; Niveau haut: +7.115; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 261; Classe: 99; Matériau: S235JR; Profil: PL4*674; Nom: GOUSSET
Tekla Quantités - Poids: 14.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.4 m2; Surface nette: 0.9 m2; Hauteur: 674.4 mm; Largeur: 4 mm; Longueur: 866.8 mm
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
BaseQuantities - Width: 674.407 mm; NetArea: 0.933163 m2; GrossArea: 0.584587 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00184449 m3; GrossVolume: 0.00184449 m3

# IfcPlate: PL4*801 (6)
In: Undefined
Description: PL4*801; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +4.704; Niveau haut: +5.698; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 261; Classe: 99; Matériau: S235JR; Profil: PL4*801; Nom: GOUSSET
Tekla Quantités - Poids: 23.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.3 m2; Surface nette: 1.5 m2; Hauteur: 801 mm; Largeur: 4 mm; Longueur: 994.6 mm
BaseQuantities - Width: 800.996 mm; NetArea: 1.50619 m2; GrossArea: 0.796643 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00298459 m3; GrossVolume: 0.00298459 m3
